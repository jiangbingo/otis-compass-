# Keil uVision project KeyBoard.uvproj, settings and files
target KeyBoard (ARM-ADS)
  device: LPC1224/101 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: KeyBoard +hex
  c flags: Optim=1
  c include: .\Common;.\Driver\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Main
    ./Main/: main.c main.h globle.h globle.c
    ./SpiOut/: SpiOut.h SpiOutDef.h SpiOutFunc.c SpiOutFunc.h SpiOutProtocol.c SpiOutProtocol.h
    ./KeyScan/: XY_Key_Scan.h XY_Key_Scan_Def.h XY_Key_Scan_Func.c XY_Key_Scan_Func.h
    ./UART/: uart0.c uart0.h Uart_FIFO.c Uart_FIFO.h UartProtocol.c UartProtocol.h
  group Common
    ./Common/: core_cm0.c system_LPC11xx.c clkconfig.h core_cm0.h LPC11xx.h system_LPC11xx.h type.h startup_LPC11xx.s
  group T1
    ./T1/: T1.c T1.h
    ./T0/: T0.c T0.h
